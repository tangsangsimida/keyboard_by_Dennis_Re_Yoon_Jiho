File: VL830/VL830/VL830.kicad_sch (KiCad schematic)
At the start: 1 part, among them U1 VL830

Commit message: VL830_30
Parts:
- removed U1: VL830, symbol New_Library:VL830
